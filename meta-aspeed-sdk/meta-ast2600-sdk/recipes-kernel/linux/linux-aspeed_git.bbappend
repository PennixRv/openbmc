FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-debug-info-to-ssif_bmc.c.patch"

