FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-debug-code-for-host-cmd-manager.cpp.patch"

